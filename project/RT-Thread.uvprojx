# Keil uVision project RT-Thread.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: RT-Thread
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\rtthread\3.0.3\include;..\rtthread\3.0.3\libcpu\arm\cortex-m7;..\rtthread\3.0.3\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../user/: main.c rtconfig.h
  group rtt/ports
    ../rtthread/3.0.3/libcpu/arm/cortex-m7/: cpuport.c context_rvds.s
  group rtt/source
    ../rtthread/3.0.3/include/: rtdef.h
    ../rtthread/3.0.3/src/: thread.c scheduler.c object.c kservice.c idle.c clock.c irq.c timer.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
